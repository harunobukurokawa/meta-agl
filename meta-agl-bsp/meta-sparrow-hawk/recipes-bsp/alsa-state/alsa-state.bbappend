FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE = "sparrow-hawk"

PACKAGE_ARCH = "${MACHINE_ARCH}"

