PACKAGECONFIG = "systemd systemd-watchdog systemd-journal"
